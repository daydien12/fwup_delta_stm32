# Keil uVision project gpio_blynk.uvprojx, settings and files
target GPIO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio_blynk +hex
  AfterMake: C:\Keil_v517\ARM\ARMCC\bin\fromelf.exe --bin Objects\gpio_blynk.axf --output Objects\gpio_blynk.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8003000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ../USER/: Delay.c main.c debug.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
