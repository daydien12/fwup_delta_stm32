# Keil uVision project fwup_delta.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fwup_delta
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\MDK;..\USER\FATFS_V0.09\src;..\USER\SPI_SD_Card;..\USER\delta;..\USER;..\USER\frame_msg;..\USER\handle_msg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group spi
    ../USER/SPI_SD_Card/: SPI_MSD0_Driver.c
  group sd_card
    ../USER/FATFS_V0.09/src/: ccsbcs.c diskio.c ff.c
  group project
    ../USER/: lib_sd.c main.c usart.c flash.c delay.c
  group delta
    ../USER/delta/: delta.c
  group msg_frame
    ../USER/frame_msg/: bts_frame_message.c bts_get_message.c bts_convert.c
  group msg_handle
    ../USER/handle_msg/: handle_msg.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
